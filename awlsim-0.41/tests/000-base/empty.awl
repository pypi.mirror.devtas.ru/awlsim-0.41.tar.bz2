ORGANIZATION_BLOCK OB 1
BEGIN
	CALL SFC 46 // STOP CPU
END_ORGANIZATION_BLOCK
