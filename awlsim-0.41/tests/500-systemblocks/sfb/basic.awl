ORGANIZATION_BLOCK OB 1
BEGIN
	CALL		SFB -1, DB 1
	__ASSERT==	__STW BIE,	1


	CALL SFC 46 // STOP CPU
END_ORGANIZATION_BLOCK


DATA_BLOCK DB 1
	SFB -1
BEGIN
END_DATA_BLOCK
