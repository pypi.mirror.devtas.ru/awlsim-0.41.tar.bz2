ORGANIZATION_BLOCK OB 1
BEGIN
	// Test SFC -1 "__SFC_NOP"
	CALL		SFC -1
	__ASSERT==	__STW BIE,	1


	CALL SFC 46 // STOP CPU
END_ORGANIZATION_BLOCK
